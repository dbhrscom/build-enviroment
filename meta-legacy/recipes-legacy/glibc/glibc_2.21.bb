require conf/license/license-gplv2.inc